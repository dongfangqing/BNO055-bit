# Keil uVision project BNO055_DEMO.uvprojx, settings and files
target BNO055_DEMO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BNO055_DEMO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\user;..\user\RCC;..\user\SysTick;..\user\led;..\user\USART;..\user\ST_string;..\user\iic_gpio;..\user\BNO055
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RCC
    ../user/RCC/: sys_rcc.c
  group SysTick
    ../user/SysTick/: SysTick.c
  group LED
    ../user/led/: led_driver.c
  group ST_string
    ../user/ST_string/: ST_string.c
  group USART
    ../user/USART/: usart_driver.c
  group IIC_GPIO
    ../user/iic_gpio/: i2c_gpio.c
  group BNO055
    ../user/BNO055/: bno055.c bno055_support.c
  group USER
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
